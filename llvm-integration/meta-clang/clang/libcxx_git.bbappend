require llvm-integration/common/swift-llvm-source.inc
